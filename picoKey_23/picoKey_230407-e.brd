# Repository hkr352/picoKey

File README.md:

# picoKey

- KMK 

- numeric keypad
- calculator

- kailh low profile key
- Full Color LED
- LCD

## EAGLE design picoKey_23/picoKey_230407-e.brd

Parts:
D1, D2, D3, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: 1N4148WS123; SOD-123
D21: 1N4148WS; SOD-123
LED0: LEDCHIP-LED0603; CHIP-LED0603
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19: SK6812MINI-EH; SK6812MINIE-H
Q1: MOSFET-P; SOT-23
Q2: MOSFET-NSOT-23; SOT-23
R1, R4, R7, R8: 100k; R0603
R2: 100R; R0603
R3: 200k; R0603
R5, R6: 4.7k; R0603
R9: 1k; R0603
S1, S2, S3, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20: CPG135001D02V2; KAILH_CHOC_V2
TP1, TP2, TP3, TP4: TPTP06R; TP06R
U1: CHG-4056
U2: FEATHER_WING_OLED
X1: RASPBERRYPI_PICO_RPI_PICO_MY-MY; RASPBERRYPI_PICO_RPI_PICO_MY

Connections:
3V3: Q2.3 (G), R5.2, R6.2, R7.1, U2.15 (+3V3), X1.3V3
4.2V: Q1.2 (D), R1.1, R3.2, U1.OUT+
AD2: R3.1, R4.2, X1.GP28_A2
A_BTN: U2.26 (A), X1.GP26_A0
B_BTN: U2.25 (B), X1.GP27_A1
COL1: S1.1, S5.1, S9.1, S13.1, S17.1, X1.GP21
COL2: S2.1, S6.1, S10.1, S14.1, S18.1, X1.GP20
COL3: S3.1, S7.1, S11.1, S15.1, S19.1, X1.GP19
COL4: S8.1, S12.1, S16.1, S20.1, X1.GP18
C_BTN: U2.24 (C), X1.GP6
GND: LED0.C, LED1.3 (GND), LED2.3 (GND), LED3.3 (GND), LED4.3 (GND), LED5.3 (GND), LED6.3 (GND), LED7.3 (GND), LED8.3 (GND), LED9.3 (GND), LED10.3 (GND), LED11.3 (GND), LED12.3 (GND), LED13.3 (GND), LED14.3 (GND), LED15.3 (GND), LED16.3 (GND), LED17.3 (GND), LED18.3 (GND), LED19.3 (GND), R4.1, U1.IN-, U1.OUT-, U2.13 (GND), X1.GND@8 (GND)
LED: Q2.1 (S), R7.2, X1.GP22
LED1: LED1.4 (DIN), Q2.2 (D), R8.2
LED2: LED1.2 (DOUT), LED2.4 (DIN)
LED3: LED2.2 (DOUT), LED3.4 (DIN)
LED4: LED3.2 (DOUT), LED4.4 (DIN)
LED5: LED4.2 (DOUT), LED5.4 (DIN)
LED6: LED5.2 (DOUT), LED6.4 (DIN)
LED7: LED6.2 (DOUT), LED7.4 (DIN)
LED8: LED7.2 (DOUT), LED8.4 (DIN)
LED9: LED8.2 (DOUT), LED9.4 (DIN)
LED10: LED9.2 (DOUT), LED10.4 (DIN)
LED11: LED10.2 (DOUT), LED11.4 (DIN)
LED12: LED11.2 (DOUT), LED12.4 (DIN)
LED13: LED12.2 (DOUT), LED13.4 (DIN)
LED14: LED13.2 (DOUT), LED14.4 (DIN)
LED15: LED14.2 (DOUT), LED15.4 (DIN)
LED16: LED15.2 (DOUT), LED16.4 (DIN)
LED17: LED16.2 (DOUT), LED17.4 (DIN)
LED18: LED17.2 (DOUT), LED18.4 (DIN)
LED19: LED18.2 (DOUT), LED19.4 (DIN)
LED20: LED19.2 (DOUT), TP1.TP
unnamed: D1.A, S1.2
unnamed: D2.A, S2.2
unnamed: D3.A, S3.2
unnamed: D5.A, S5.2
unnamed: D6.A, S6.2
unnamed: D7.A, S7.2
unnamed: D8.A, S8.2
unnamed: D9.A, S9.2
unnamed: D10.A, S10.2
unnamed: D11.A, S11.2
unnamed: D12.A, S12.2
unnamed: D13.A, S13.2
unnamed: D14.A, S14.2
unnamed: D15.A, S15.2
unnamed: D16.A, S16.2
unnamed: D17.A, S17.2
unnamed: D18.A, S18.2
unnamed: LED0.A, R9.2
unnamed: D20.A, S20.2
unnamed: D19.A, S19.2
unnamed: D21.A, R2.2, X1.VBUS
unnamed: D21.K (C), U1.IN+
unnamed: Q1.3 (G), R1.2, R2.1
unnamed: TP2.TP, X1.ADC_VREF
ROW1: D1.K, D2.K, D3.K, X1.GP15
ROW2: D5.K, D6.K, D7.K, D8.K, X1.GP14
ROW3: D9.K, D10.K, D11.K, D12.K, X1.GP13
ROW4: D13.K, D14.K, D15.K, D16.K, X1.GP12
ROW5: D17.K, D18.K, D19.K, D20.K, X1.GP11
RX: TP4.TP, X1.GP1
SCL: R6.1, U2.27 (SCL), X1.GP5
SDA: R5.1, U2.28 (SDA), X1.GP4
TX: TP3.TP, X1.GP0
VSYS: LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), Q1.1 (S), R8.1, R9.1, X1.VSYS

Notes on the sheet:
・USB-BLE切り替えスイッチ ・テンキー・電卓切り替えスイッチ

Board: 2 copper layers, 79.9 x 125.9 mm, 78 parts (49 on the bottom side), 66 nets.

Other parts of the board:
U$1: STABILIZER

## EAGLE design picoKey_23/picoKey_230406.brd

Board: 2 copper layers, 78.0 x 124.9 mm, 76 parts (27 on the bottom side), 47 nets, no tracks yet.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: 1N4148WS; SODFL2512X90N
D21: SOD-123
LED0: CHIP-LED0603
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20: SK6812MINI-E; SK6812MINIE
Q1, Q2: SOT-23
R1, R4, R7, R8: 100k; R0603
R2: 100R; R0603
R3: 200k; R0603
R5, R6: 4.7k; R0603
R9: 1k; R0603
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20: CPG135001D02V2; KAILH_CHOC_V2
U1: CHG-4056
U$1: FEATHER_WING_OLED
X1: RASPBERRYPI_PICO_RPI_PICO_MY

Connections:
3V3: Q2.3, R5.2, R6.2, R7.1, U$1.15, X1.3V3
AD2: R3.1, R4.2, X1.GP28_A2
A_BTN: U$1.26, X1.GP26_A0
B_BTN: U$1.25, X1.GP27_A1
COL1: S1.1, S5.1, S9.1, S13.1, S17.1, X1.GP21
COL2: S2.1, S6.1, S10.1, S14.1, S18.1, X1.GP20
COL3: S3.1, S7.1, S11.1, S15.1, S19.1, X1.GP19
COL4: S4.1, S8.1, S12.1, S16.1, S20.1, X1.GP18
GND: LED0.C, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, LED6.3, LED7.3, LED8.3, LED9.3, LED10.3, LED11.3, LED12.3, LED13.3, LED14.3, LED15.3, LED16.3, LED17.3, LED18.3, LED19.3, LED20.3, R4.1, U1.IN-, U1.OUT-, U$1.1, X1.GND@8
LED: Q2.1, R7.2, X1.GP22
LED1: LED1.4, LED5.4, LED9.4, LED13.4, LED17.4, Q2.2, R8.2
unnamed: D1.2, S1.2
unnamed: D2.2, S2.2
unnamed: D3.2, S3.2
unnamed: D4.2, S4.2
unnamed: D5.2, S5.2
unnamed: D6.2, S6.2
unnamed: D7.2, S7.2
unnamed: D8.2, S8.2
unnamed: D9.2, S9.2
unnamed: D10.2, S10.2
unnamed: D11.2, S11.2
unnamed: D12.2, S12.2
unnamed: D13.2, S13.2
unnamed: D14.2, S14.2
unnamed: D15.2, S15.2
unnamed: D16.2, S16.2
unnamed: D17.2, S17.2
unnamed: D18.2, S18.2
unnamed: LED0.A, R9.2
unnamed: D20.2, S20.2
unnamed: D19.2, S19.2
unnamed: LED2.2, LED3.4, LED6.2, LED7.4, LED10.2, LED11.4, LED14.2, LED15.4, LED18.2, LED19.4
unnamed: LED3.2, LED4.4, LED7.2, LED8.4, LED11.2, LED12.4, LED15.2, LED16.4, LED19.2, LED20.4
unnamed: Q1.2, R1.1, R3.2, U1.OUT+
unnamed: D21.A, R2.2, X1.VBUS
unnamed: LED1.2, LED2.4, LED5.2, LED6.4, LED9.2, LED10.4, LED13.2, LED14.4, LED17.2, LED18.4
unnamed: D21.K, U1.IN+
unnamed: Q1.3, R1.2, R2.1
ROW1: D1.1, D2.1, D3.1, D4.1, X1.GP15
ROW2: D5.1, D6.1, D7.1, D8.1, X1.GP14
ROW3: D9.1, D10.1, D11.1, D12.1, X1.GP13
ROW4: D13.1, D14.1, D15.1, D16.1, X1.GP12
ROW5: D17.1, D18.1, D19.1, D20.1, X1.GP11
SCL: R6.1, U$1.27, X1.GP5
SDA: R5.1, U$1.28, X1.GP4
VSYS: LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED7.1, LED8.1, LED9.1, LED10.1, LED11.1, LED12.1, LED13.1, LED14.1, LED15.1, LED16.1, LED17.1, LED18.1, LED19.1, LED20.1, Q1.1, R8.1, R9.1, X1.VSYS

## Commit log

2023-04-07 init
2023-04-07 edit enter
2023-04-09 add stabilizer
2024-02-22 add code
